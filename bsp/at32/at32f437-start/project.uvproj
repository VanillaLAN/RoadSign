# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: -AT32F437VGT7 ArteryTek
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x08000000-0x083EFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, AT32F437VGT7, __RTTHREAD__
  c include: ..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\device_support;..\libraries\rt_drivers;board;board\inc;applications;..\..\..\components\libc\compilers\common\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\libraries\usbotg_library\inc;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\libc\posix\io\eventfd;.;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\libraries\rt_drivers\config;..\..\..\components\libc\compilers\common\extension;..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\core_support;..\..\..\components\drivers\include;..\libraries\AT32F435_437_Firmware_Library\drivers\inc;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
    ../libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/AT32F435_437_Firmware_Library/drivers/src/: at32f435_437_gpio.c at32f435_437_exint.c at32f435_437_i2c.c at32f435_437_acc.c at32f435_437_dac.c at32f435_437_qspi.c at32f435_437_crc.c at32f435_437_dma.c at32f435_437_can.c at32f435_437_ertc.c at32f435_437_usb.c at32f435_437_spi.c at32f435_437_pwc.c at32f435_437_tmr.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_xmc.c at32f435_437_debug.c at32f435_437_dvp.c at32f435_437_misc.c at32f435_437_usart.c at32f435_437_wdt.c at32f435_437_flash.c at32f435_437_adc.c at32f435_437_wwdt.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_crm.c
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/: system_at32f435_437.c
