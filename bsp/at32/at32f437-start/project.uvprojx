# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437VGT7, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, __STDC_LIMIT_MACROS, RT_USING_LIBC
  c misc: --gnu
  c include: ..\..\..\include;..\libraries\AT32F435_437_Firmware_Library\drivers\inc;..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\core_support;..\..\..\components\libc\posix\io\epoll;board\inc;..\..\..\components\net\netdev\include;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension;packages\kawaii-mqtt-latest\common;..\libraries\rt_drivers;..\..\..\components\legacy\usb\usbhost;..\..\..\components\net\sal\include;..\..\..\components\legacy\usb\usbhost\include;applications;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\components\net\sal\include\socket\sys_socket;packages\kawaii-mqtt-latest\platform\RT-Thread;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\legacy\usb\usbhost\class;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\gps_rmc-latest;packages\tinycrypt-latest\include;..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\device_support;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\smp_call;packages\kawaii-mqtt-latest\mqttclient;packages\cJSON-v1.7.17;packages\netutils-latest\ntp;..\libraries\usbotg_library\inc;..\..\..\components\libc\posix\ipc;packages\webclient-v2.1.2\inc;packages\kawaii-mqtt-latest\mqtt;packages\kawaii-mqtt-latest\network;.;..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;board;..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\fal\inc;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\libraries\rt_drivers\config;..\..\..\libcpu\arm\common;..\..\..\components\net\lwip\port;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\finsh;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\impl;..\..\..\components\legacy\include
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON.c cJSON_Utils.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
    ../libraries/rt_drivers/: drv_common.c drv_flash.c drv_gpio.c drv_usart.c drv_usbotgh.c
  group Fal
    ../../../components/fal/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c cmd.c msh_parse.c msh_file.c msh.c
  group gps_rmc
    packages/gps_rmc-latest/: gps_rmc.c
    packages/gps_rmc-latest/example/: rtt_gps_rmc_example.c
  group kawaii_mqtt
    packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
    packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_mutex.c platform_memory.c platform_timer.c platform_thread.c platform_net_socket.c
    packages/kawaii-mqtt-latest/common/: random.c mqtt_list.c
    packages/kawaii-mqtt-latest/mqtt/: MQTTSubscribeClient.c MQTTFormat.c MQTTSerializePublish.c MQTTPacket.c MQTTConnectClient.c MQTTUnsubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeServer.c MQTTDeserializePublish.c MQTTConnectServer.c
    packages/kawaii-mqtt-latest/network/: nettype_tls.c network.c nettype_tcp.c
    packages/kawaii-mqtt-latest/test/: test.c test_ca.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/AT32F435_437_Firmware_Library/drivers/src/: at32f435_437_crc.c at32f435_437_usb.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_sdio.c at32f435_437_flash.c at32f435_437_ertc.c at32f435_437_usart.c at32f435_437_can.c at32f435_437_dac.c at32f435_437_crm.c at32f435_437_spi.c at32f435_437_gpio.c at32f435_437_adc.c at32f435_437_qspi.c at32f435_437_edma.c at32f435_437_debug.c at32f435_437_xmc.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_wwdt.c at32f435_437_wdt.c at32f435_437_acc.c at32f435_437_i2c.c at32f435_437_exint.c at32f435_437_scfg.c at32f435_437_tmr.c at32f435_437_emac.c
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/: system_at32f435_437.c
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group NetUtils
    packages/netutils-latest/ntp/: ntp.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: usbhost_core.c usbhost.c driver.c hub.c
    ../../../components/legacy/usb/usbhost/class/: mass.c udisk.c rndis_dev.c usbh_rndis.c
    ./toolkit/: toolkit.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group TinyCrypt
    packages/tinycrypt-latest/src/: tiny_sha2.c tiny_aes.c tiny_sha1.c tiny_md5.c tiny_base64.c
  group usbotg_library
    ../libraries/usbotg_library/src/: usb_core.c usbh_ctrl.c usbh_core.c usbh_int.c
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c webclient_file.c
    packages/webclient-v2.1.2/samples/: webclient_post_sample.c webclient_get_sample.c
