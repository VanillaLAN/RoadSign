# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: AT32F437VGT7_v2 ArteryTek -AT32F437VGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; AT32F437VGT7; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\posix\ipc; .; board\inc; board; ..\libraries\usbotg_library\inc; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\compilers\common\include; ..\libraries\AT32F435_437_Firmware_Library\drivers\inc; ..\libraries\rt_drivers; applications; ..\libraries\rt_drivers\config; ..\..\..\libcpu\arm\common; ..\..\..\include; ..\..\..\components\libc\posix\io\poll; ..\..\..\libcpu\arm\cortex-m4; ..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\device_support; ..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\core_support; ..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/startup/iar/: startup_at32f435_437.s
    ../libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    ../libraries/AT32F435_437_Firmware_Library/drivers/src/: at32f435_437_gpio.c at32f435_437_exint.c at32f435_437_i2c.c at32f435_437_acc.c at32f435_437_dac.c at32f435_437_qspi.c at32f435_437_crc.c at32f435_437_dma.c at32f435_437_can.c at32f435_437_ertc.c at32f435_437_usb.c at32f435_437_spi.c at32f435_437_pwc.c at32f435_437_tmr.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_xmc.c at32f435_437_debug.c at32f435_437_dvp.c at32f435_437_misc.c at32f435_437_usart.c at32f435_437_wdt.c at32f435_437_flash.c at32f435_437_adc.c at32f435_437_wwdt.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_crm.c
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/: system_at32f435_437.c
