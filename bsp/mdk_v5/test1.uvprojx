# Keil uVision project test1.uvprojx, settings and files
target rt_thread_at32f437 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoadSign +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, AT32F437VGT7, __RTTHREAD__
  c misc: --gnu
  c include: .\;.\applications;.\board\inc;..\libraries\rt_drivers;..\libraries\rt_drivers\config;..\libraries\usbotg_library\inc;..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\core_support;..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\device_support;..\libraries\AT32F435_437_Firmware_Library\drivers\inc;..\..\components\dfs\dfs_v1\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\include;..\..\components\drivers;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\spi\sfud\inc;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common\extension;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\compilers\common\include;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\ipc;..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\components\net\lwip\lwip-2.0.3\src\include\posix;..\..\components\net\lwip\port;..\..\components\net\lwip\port\netif;..\..\components\net\sal\impl;..\..\components\net\sal\include;..\..\components\net\sal\include\dfs_net;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;.\packages\kawaii-mqtt-latest\mqtt;.\packages\kawaii-mqtt-latest\mqttclient;.\packages\kawaii-mqtt-latest\common;.\packages\kawaii-mqtt-latest\common\log;.\packages\kawaii-mqtt-latest\platform\RT-Thread;.\packages\kawaii-mqtt-latest\network;.\packages\OneNet\inc;.\packages\tinycrypt-latest\include;.\packages\cJSON-v1.7.17;.\packages\webclient-v2.1.2\inc;.\packages\fal-v0.4.0;.\packages\gps_rmc-latest;..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\stm32f429_flash.sct
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
    ../../src/klibc/: kstdio.c kstring.c
  group Applications
    applications/: main.c at32f435_437_int.c gps.c
  group Drivers
    ./board/src/: board.c at32_msp.c
    ../libraries/rt_drivers/: drv_common.c drv_sdram.c drv_rtc.c drv_gpio.c drv_usart.c drv_usbotgh.c
    ./packages/OneNet/src/: OneNet.c
    ./packages/cJSON-v1.7.17/: cJSON.c
    ./packages/tinycrypt-latest/src/: tiny_base64.c tiny_sha1.c
    ./packages/webclient-v2.1.2/src/: webclient.c
    ./packages/gps_rmc-latest/: gps_rmc.c
  group firmware
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/: system_at32f435_437.c
    ../libraries/AT32F435_437_Firmware_Library/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group NetUtils
    ./packages/netutils-latest/ntp/: ntp.c
  group CORTEX-M4
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Filesystem
    ../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group DeviceDrivers
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/mtd/: mtd_nor.c
    ../../components/drivers/rtc/: dev_rtc.c
    ../../components/drivers/serial/: dev_serial.c
    ../../components/drivers/spi/: dev_spi_core.c dev_spi.c dev_spi_flash_sfud.c
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group rt_usbh
    ../libraries/usbotg_library/src/: usb_core.c usbh_core.c usbh_ctrl.c usbh_int.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh_parse.c msh.c msh_file.c
  group libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group IwIP
    ../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group SAL
    ../../components/net/sal/src/: sal_socket.c
    ../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal/impl/: af_inet_lwip.c
    ../../components/net/sal/dfs_net/: dfs_net.c
