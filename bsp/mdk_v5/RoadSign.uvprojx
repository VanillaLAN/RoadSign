# Keil uVision project RoadSign.uvprojx, settings and files
target rt_thread_at32f437 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoadSign +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, AT32F437VGT7, __RTTHREAD__
  c misc: --gnu
  c include: .\;.\applications;.\board\inc;..\libraries\rt_drivers;..\libraries\rt_drivers\config;..\libraries\usbotg_library\inc;..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\core_support;..\libraries\AT32F435_437_Firmware_Library\cmsis\cm4\device_support;..\libraries\AT32F435_437_Firmware_Library\drivers\inc;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\dfs\dfs_v1\include;..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\components\legacy\dfs;..\..\components\drivers;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\spi\sfud\inc;..\..\components\fal\inc;..\..\components\fal\samples\porting;..\..\components\finsh;..\..\components\legacy\usb\usbhost\class;..\..\components\legacy\usb\usbdevice\class;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common\extension;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\compilers\common\include;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\ipc;..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\components\net\lwip\port;..\..\components\net\lwip\port\netif;..\..\components\net\netdev\include;..\..\components\net\sal\impl;..\..\components\net\sal\include;..\..\components\net\sal\include\dfs_net;..\..\components\net\sal\include\socket;..\..\components\net\sal\include\socket\sys_socket;..\..\include;.\packages\kawaii-mqtt-latest\mqtt;.\packages\kawaii-mqtt-latest\mqttclient;.\packages\kawaii-mqtt-latest\common;.\packages\kawaii-mqtt-latest\common\log;.\packages\kawaii-mqtt-latest\platform\RT-Thread;.\packages\kawaii-mqtt-latest\network;.\packages\OneNet\inc;.\packages\tinycrypt-latest\include;.\packages\cJSON-v1.7.17;.\packages\webclient-v2.1.2\inc;.\packages\gps_rmc-latest;..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\stm32f429_flash.sct
  group Applications
    applications/: main.c
  group cJSON
    ./packages/cJSON-v1.7.17/: cJSON.c cJSON_Utils.c
  group CORTEX-M4
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/mtd/: mtd_nor.c
    ../../components/drivers/rtc/: dev_rtc.c
    ../../components/drivers/serial/: dev_serial.c
    ../../components/drivers/spi/: dev_spi_core.c dev_spi.c dev_spi_flash_sfud.c
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    ./board/src/: board.c at32_msp.c
    applications/: at32f435_437_int.c
    ../libraries/rt_drivers/: drv_common.c drv_gpio.c drv_rtc.c drv_usbotgh.c drv_usart.c
  group fal
    ../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../../components/fal/samples/porting/: fal_flash_at32_port.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh_parse.c msh.c msh_file.c
  group Filesystem
    ../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/libc/posix/io/poll/: poll.c select.c
  group kawaii_mqtt
    ./packages/kawaii-mqtt-latest/common/: mqtt_list.c random.c
    ./packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
    ./packages/kawaii-mqtt-latest/mqtt/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ./packages/kawaii-mqtt-latest/network/: nettype_tcp.c nettype_tls.c network.c
    ./packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
    ./packages/kawaii-mqtt-latest/test/: test.c test_ca.c
  group Kernel
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_std.c rt_vsscanf.c
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c cunistd.c cwchar.c ctime.c
  group lwIP
    ../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group netdev
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group NetUtils
    ./packages/netutils-latest/ntp/: ntp.c
  group OneNet
    ./packages/OneNet/src/: OneNet.c
  group rt_usbh
    ../libraries/usbotg_library/src/: usbh_int.c usb_core.c usbh_core.c usbh_ctrl.c
    ../../components/legacy/usb/usbhost/core/: driver.c hub.c usbhost.c usbhost_core.c
    ../../components/legacy/usb/usbhost/class/: mass.c udisk.c rndis_dev.c usbh_rndis.c
  group SAL
    ../../components/net/sal/dfs_net/: dfs_net.c
    ../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal/src/: sal_socket.c
    ../../components/net/sal/impl/: af_inet_lwip.c
  group firmware
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
    ../libraries/AT32F435_437_Firmware_Library/cmsis/cm4/device_support/: system_at32f435_437.c
    ../libraries/AT32F435_437_Firmware_Library/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group TinyCrypt
    ./packages/tinycrypt-latest/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
  group toolkit
    ../../toolkit/: toolkit.c
  group WebClient
    ./packages/webclient-v2.1.2/src/: webclient.c webclient_file.c
    ./packages/webclient-v2.1.2/samples/: webclient_get_sample.c webclient_post_sample.c
  group gps_rmc
    ./packages/gps_rmc-latest/: gps_rmc.c
    applications/: gps.c
